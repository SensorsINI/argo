File: pcb/anemometer/WindSensor/WindSensor.kicad_pcb (KiCad board)
At the start: 2 copper layers, 20 x 20 mm, 8 parts

Commit message: add wind sensor PDFs
Other:
- net class Default removed
